<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart0_ex.ewp</path>
    </project>
    <batchBuild />
</workspace>
